File: capable_jetson_carrier.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: Checkpoint
Other:
- added sheet MCU (mcu.kicad_sch)
